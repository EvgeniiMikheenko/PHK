# Keil uVision project MobDet_V2.uvprojx, settings and files
target MobDet_V2 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L152C6 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MobDet_V2
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xB
  c misc: --C99
  c include: ../Inc;   ../Drivers/STM32L1xx_HAL_Driver/Inc;   ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;   ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;   ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;   ../Drivers/CMSIS/Device/ST/STM32L1xx/Include;   ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  link misc: --diag_suppress=L6329
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_uart.c stm32l1xx_hal_adc.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_tim.c stm32l1xx_hal_pwr.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_i2c.c stm32l1xx_hal_cortex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c
  group Application/MDK-ARM
    ./: startup_stm32l152xb.s
  group Application/User
    ../Src/: main.c usbd_conf.c stm32l1xx_it.c usb_device.c gpio.c usbd_cdc_if.c usbd_desc.c adc.c dma.c usart.c tim.c stm32l1xx_hal_msp.c i2c.c crc16.c mb.c mb_slave.c modbus_config.c
software components: CMSIS:CORE 4.1.0
